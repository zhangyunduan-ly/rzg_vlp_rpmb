include include/u-boot-${MACHINE}.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
