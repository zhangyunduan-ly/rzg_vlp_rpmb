include include/flash-writer-${MACHINE}.inc
