require linux-renesas/linux-renesas-${MACHINE}.inc

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"