KERNEL_URL = "git://github.com/zhangyunduan-ly/rz_linux-cip-ly.git"

KERNEL_BRANCH = "dev-ly-mod-us"
KERNEL_REV = "46376a9ef350f1abf07255120a647ea84a833bf8"
