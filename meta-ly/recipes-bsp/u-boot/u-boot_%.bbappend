UBOOT_URI = "git://github.com/zhangyunduan-ly/renesas-u-boot-cip-ly.git;protocol=https"
UBOOT_BRANCH = "dev-ly-dc12"
UBOOT_REV = "bfc7a9c6b6271b164118b4422e82854c457cd02d"