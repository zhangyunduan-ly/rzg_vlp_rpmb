TFA_URI = "git://github.com/zhangyunduan-ly/rzg_trusted-firmware-a-ly.git;protocol=https"
TFA_REV = "e3b8cf9008b764bf58a87f29cde367b4c703f641"
TFA_BRANCH = "dev-ly-ph"