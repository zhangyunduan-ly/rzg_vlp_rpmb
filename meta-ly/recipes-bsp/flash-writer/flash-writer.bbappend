FLASH_WRITER_URL = "git://github.com/zhangyunduan-ly/rzg2_flash_writer_ly"
BRANCH = "dev-ly-ph"

SRC_URI = "${FLASH_WRITER_URL};protocol=https;branch=${BRANCH}"
SRCREV = "a3fc365626f1ad5198cadf2aa4509ea4e58353a5"
