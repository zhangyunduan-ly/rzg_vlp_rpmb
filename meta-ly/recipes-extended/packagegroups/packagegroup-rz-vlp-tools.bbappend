RDEPENDS:packagegroup-rz-vlp-tools-multimedia:remove = " \
	kernel-module-uvcvideo \
	libdrm \
 	libdrm-tests \
	v4l-utils \
	audio-init \
	v4l2-init \
 	yavta \
	"
