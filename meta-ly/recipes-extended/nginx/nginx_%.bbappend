PACKAGECONFIG:append = " stream"