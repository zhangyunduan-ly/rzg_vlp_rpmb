PACKAGECONFIG:append = " eap-mschapv2"